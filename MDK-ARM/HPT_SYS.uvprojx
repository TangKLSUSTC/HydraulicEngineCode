# Keil uVision project HPT_SYS.uvprojx, settings and files
target HPT_V3.1 (6160000::V6.16::ARMCLANG)
  device: STM32F401CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: HPT_SYS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xE,DEBUG,__PERF_CNT_USE_RTOS__,HPT_V3_1
  c include: ../RT-Thread;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/RealThread_RTOS/include/;../Middlewares/Third_Party/RealThread_RTOS/bsp/_template/cubemx_config;../Middlewares/Third_Party/RealThread_RTOS/finsh/;../Middlewares/Third_Party/RealThread_RTOS/components/finsh;..\Packages\app_main_control;..\Packages\core_delay;..\Packages\dev_ad7490;..\Packages\dev_common;..\Packages\perf_counter;..\Packages\services;..\Packages\usart_dma_io;..\Packages;..\Packages\dev_tca9539
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RealThread_RTOS/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../Middlewares/Third_Party/RealThread_RTOS/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../Middlewares/Third_Party/RealThread_RTOS/bsp/_template/cubemx_config/: board.c
  group Middlewares/RT-Thread/RTOS/shell
    ../Middlewares/Third_Party/RealThread_RTOS/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group PC/DMA_IO
    ../Packages/usart_dma_io/: dma_io_declaration.c usart_dma_io.c
  group PC/perf_counter
    ../Packages/perf_counter/: perf_counter.c perf_os_patch_rt_thread.c systick_wrapper_ual.s
  group PC/core_delay
    ../Packages/core_delay/: core_delay.c
  group PC/drivers
    ../Packages/dev_ad7490/: dev_ad7490.c
    ../Packages/dev_common/: dev_common.c
    ../Packages/dev_tca9539/: dev_tca9539.c
  group service/LED_signal
    ../Packages/services/: serv_led_sign.c
  group service/KEY_listener
    ../Packages/services/: serv_key_listener.c
  group service/AD7490_Fetcher
    ../Packages/services/: serv_ad7490_fetcher.c
  group APP/main_control
    ../Packages/app_main_control/: app_main_control.c
  group service/Common
    ../Packages/services/: serv_global.c ringbuffer.c
  group service/TCA_io
    ../Packages/services/: serv_tca_io.c
target HPT_V3.2 (6160000::V6.16::ARMCLANG)
  device: STM32F401CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HPT_SYS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xE,DEBUG,__PERF_CNT_USE_RTOS__,HPT_V3_2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 5.5.0
